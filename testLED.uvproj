# Keil uVision project testLED.uvproj, settings and files
target Debug (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: testLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source
    ./src/: main.c delay.c uart.c led.c ds1302.c wdt.c ds18b20.c redctrl.c timer.c task.c text.c eeprom.c
  group includes
    ./inc/: delay.h includes.h NEW_8051.H uart.h wdt.h led.h ds1302.h redctrl.h ds18b20.h timer.h task.h eeprom.h
